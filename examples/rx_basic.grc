<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>2.41e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e6</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>variable_uhd_device3_0</value></param>
<param><key>dev_addr</key><value>type=x300</value></param>
<param><key>dev_args</key><value>""</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>./zluudgRX_dump.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_1</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>195</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_radio</key>
<param><key>id</key><value>uhd_rfnoc_streamer_radio_0_0</value></param>
<param><key>rx_bandwidth0</key><value>56e6</value></param>
<param><key>ant0</key><value>"RX2"</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>dcenable0</key><value>True</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>lo_export0</key><value>False</value></param>
<param><key>lo_source0</key><value>"internal"</value></param>
<param><key>rx_bandwidth1</key><value>56e6</value></param>
<param><key>ant1</key><value></value></param>
<param><key>freq1</key><value>1.982e9</value></param>
<param><key>dcenable1</key><value>True</value></param>
<param><key>gain1</key><value>20</value></param>
<param><key>lo_export1</key><value>False</value></param>
<param><key>lo_source1</key><value>"internal"</value></param>
<param><key>otw_format</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>cpu_format</key><value>sc16</value></param>
<param><key>source</key><value>"internal"</value></param>
<param><key>direction</key><value>rx</value></param>
<param><key>num_channels</key><value>1</value></param>
<param><key>radio_index</key><value>0</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>stream_args</key><value></value></param>
</block>
<block>
<key>zluudgbee_chdr2pdu</key>
<param><key>id</key><value>zluudgbee_chdr2pdu_0</value></param>
<param><key>otw_format</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>type</key><value>sc16</value></param>
<param><key>mtu</key><value>2048</value></param>
</block>
<block>
<key>zluudgbee_zluudgbeeCRC</key>
<param><key>id</key><value>zluudgbee_zluudgbeeCRC_0</value></param>
<param><key>crc_mode</key><value>0</value></param>
<param><key>otw</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>enable_eob_on_stop</key><value>True</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>fpga_module_name</key><value>noc_block_zluudgCRC</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>type</key><value>sc16</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>zluudgbee_zluudgbeeRX</key>
<param><key>id</key><value>zluudgbee_zluudgbeeRX_0</value></param>
<param><key>crappy_threshold</key><value>8</value></param>
<param><key>decim_rate</key><value>100</value></param>
<param><key>otw</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>enable_eob_on_stop</key><value>True</value></param>
<param><key>fpga_module_name</key><value>noc_block_zluudgRX</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>type</key><value>sc16</value></param>
<param><key>ma_line_depth</key><value>8</value></param>
<param><key>shr_sens</key><value>20</value></param>
<param><key>shift_threshold</key><value>0.35</value></param>
<param><key>symsync_mode</key><value>1</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<connection><source_block_id>foo_wireshark_connector_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_radio_0_0</source_block_id><sink_block_id>zluudgbee_zluudgbeeRX_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zluudgbee_chdr2pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>data</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>zluudgbee_chdr2pdu_0</source_block_id><sink_block_id>foo_wireshark_connector_1</sink_block_id><source_key>data</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>zluudgbee_zluudgbeeCRC_0</source_block_id><sink_block_id>zluudgbee_chdr2pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zluudgbee_zluudgbeeRX_0</source_block_id><sink_block_id>zluudgbee_zluudgbeeCRC_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
