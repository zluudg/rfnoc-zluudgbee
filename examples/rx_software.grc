<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>2.41e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e6</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>variable_uhd_device3_0</value></param>
<param><key>dev_addr</key><value>type=x300</value></param>
<param><key>dev_args</key><value>""</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/rx_software.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.03</value></param>
<param><key>gain_omega</key><value>0.000225</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.0002</value></param>
<param><key>omega</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_1</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>195</value></param>
</block>
<block>
<key>ieee802_15_4_mac</key>
<param><key>id</key><value>ieee802_15_4_mac_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>dst</key><value>0xffff</value></param>
<param><key>dst_pan</key><value>0x1aaa</value></param>
<param><key>fcf</key><value>0x8841</value></param>
<param><key>seq_nr</key><value>0</value></param>
<param><key>src</key><value>0x3344</value></param>
</block>
<block>
<key>ieee802_15_4_packet_sink</key>
<param><key>id</key><value>ieee802_15_4_packet_sink_0</value></param>
<param><key>th</key><value>10</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>0.00016</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_ddc</key>
<param><key>id</key><value>uhd_rfnoc_streamer_ddc_0</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_ddc</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>freq</key><value>0.0</value></param>
<param><key>fullscale</key><value>1.0</value></param>
<param><key>input_rate</key><value>samp_rate</value></param>
<param><key>num_chans</key><value>1</value></param>
<param><key>output_rate</key><value>decim_rate</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_radio</key>
<param><key>id</key><value>uhd_rfnoc_streamer_radio_0</value></param>
<param><key>rx_bandwidth0</key><value>56e6</value></param>
<param><key>ant0</key><value>"RX2"</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>dcenable0</key><value>True</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>lo_export0</key><value>False</value></param>
<param><key>lo_source0</key><value>"internal"</value></param>
<param><key>rx_bandwidth1</key><value>56e6</value></param>
<param><key>ant1</key><value></value></param>
<param><key>freq1</key><value>1.982e9</value></param>
<param><key>dcenable1</key><value>True</value></param>
<param><key>gain1</key><value>20</value></param>
<param><key>lo_export1</key><value>False</value></param>
<param><key>lo_source1</key><value>"internal"</value></param>
<param><key>otw_format</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>cpu_format</key><value>fc32</value></param>
<param><key>source</key><value>"internal"</value></param>
<param><key>direction</key><value>rx</value></param>
<param><key>num_channels</key><value>1</value></param>
<param><key>radio_index</key><value>0</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>stream_args</key><value></value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>ieee802_15_4_packet_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>app out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>foo_wireshark_connector_1</sink_block_id><source_key>app out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_packet_sink_0</source_block_id><sink_block_id>ieee802_15_4_mac_0</sink_block_id><source_key>out</source_key><sink_key>pdu in</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_ddc_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_radio_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_ddc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
