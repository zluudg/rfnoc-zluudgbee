<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>variable_uhd_device3_0</value></param>
<param><key>dev_addr</key><value>type=x300</value></param>
<param><key>dev_args</key><value>""</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/zludgbee_dummycoord_software.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>195</value></param>
</block>
<block>
<key>zludgbee_software_phy</key>
<param><key>id</key><value>zludgbee_software_phy_0</value></param>
</block>
<block>
<key>zluudgbee_dummycoord</key>
<param><key>id</key><value>zluudgbee_dummycoord_1</value></param>
<param><key>epid</key><value>0x000000000000000a</value></param>
<param><key>short_addr_mode</key><value>False</value></param>
<param><key>src_addr</key><value>0x1010101010101010</value></param>
<param><key>pan_id</key><value>0xabcd</value></param>
</block>
<connection><source_block_id>foo_wireshark_connector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zludgbee_software_phy_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>rxout</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>zludgbee_software_phy_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>rxout</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>zludgbee_software_phy_0</source_block_id><sink_block_id>zluudgbee_dummycoord_1</sink_block_id><source_key>rxout</source_key><sink_key>pdu in</sink_key></connection>
<connection><source_block_id>zluudgbee_dummycoord_1</source_block_id><sink_block_id>zludgbee_software_phy_0</sink_block_id><source_key>pdu out</source_key><sink_key>txin</sink_key></connection>
</flow_graph>
